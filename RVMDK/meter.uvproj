# Keil uVision project meter.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: meter
  AfterMake: fromelf.exe --bin -o  ..\Bin\agv.bin  ..\List\meter.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,DEBUG_CAN
  c include: ..\src\FWIB;..\src\BSP;..\src\LwIP\port;..\src\LwIP\port\arch;..\src\UCOSII;..\src\LwIP\src\include;..\src\LwIP\src\include\ipv4;..\src\LwIP\src\include\ipv4\lwip;..\src\LwIP\src\include\lwip;..\src\LwIP\src\include\netif;..\src\CORE;..\src\USER;..\src\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x3b000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USR
    ../src/USER/: main.c cfg.h
    ../src/APP/: hal_process_CONTROL.c hal_process_SERVES.c hal_process_COLLECT.c hal_process_DEBUG.c Patrol_control.c
  group BSP
    ../src/BSP/: BSP.c bsp_can.c bsp_eth.c bsp_usart.c bsp_tim.c bsp_spi.c
  group CORE
    ../src/CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_cl.s
  group FWLIB
    ../src/FWIB/: misc.c stm32_eth.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UCOS
    ../src/UCOSII/: os_core.c os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSport
    ../src/UCOSII/: os_cpu_a.asm os_cfg.h os_cpu.h
  group LWIP
    ../src/LwIP/port/: ethernetif.c sys_arch.c LwIP.c
    ../src/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../src/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../src/LwIP/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c def.c timers.c
    ../src/LwIP/src/netif/: etharp.c
